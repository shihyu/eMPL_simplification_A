<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32L-DISCOVERY</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>driver</name>
      <group>
        <name>eMPL</name>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\dmpKey.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\dmpmap.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu_dmp_motion_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu_dmp_motion_driver.h</name>
        </file>
      </group>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\log.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\mlinclude.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\mlmath.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\mlos.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\mltypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\mpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\include\stdint_invensense.h</name>
        </file>
      </group>
      <group>
        <name>stm32l</name>
        <file>
          <name>$PROJ_DIR$\..\core\driver\stm32L\log_stm32l.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\stm32L\packet.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>eMPL-hal</name>
      <file>
        <name>$PROJ_DIR$\..\core\eMPL-hal\eMPL_outputs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\eMPL-hal\eMPL_outputs.h</name>
      </file>
    </group>
    <group>
      <name>mllite</name>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\data_builder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\data_builder.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\hal_outputs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\hal_outputs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\invensense.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\message_layer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\message_layer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\ml_math_func.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\ml_math_func.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\mlmath.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\mpl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\mpl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\results_holder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\results_holder.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\start_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\start_manager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\storage_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\storage_manager.h</name>
      </file>
    </group>
    <group>
      <name>mpl</name>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\accel_auto_cal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\compass_vec_cal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\fast_no_motion.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\fusion_9axis.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\gyro_tc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\heading_from_gyro.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\inv_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\invensense_adv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\libmpllib.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\mag_disturb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\motion_no_motion.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\no_gyro_fusion.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\quaternion_supervisor.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\readme.txt</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx\startup\iar\startup_stm32l1xx_md.s</name>
    </file>
  </group>
  <group>
    <name>Peripherals</name>
    <file>
      <name>$PROJ_DIR$\..\peripheral\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\peripheral\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\peripheral\uart.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash_ramfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>STM32L_DISCOVERY</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32L-DISCOVERY\stm32l_discovery_lcd.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stm32l1xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\system_stm32l1xx.c</name>
    </file>
  </group>
</project>


