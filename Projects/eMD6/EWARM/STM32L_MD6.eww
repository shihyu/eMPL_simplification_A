<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\eMD6_reorganized\eMD6_reorganized.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


