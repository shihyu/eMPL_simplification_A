# IAR project Project.ewp, settings and files
configuration STM32L-DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU9250; USE_MPU_CONFIG_FILE
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\src; ..\peripheral; ..\mpu\mpu_config; ..\mpu\mpl; ..\mpu\driver\include; ..\mpu\driver\eMPL; ..\mpu\driver\packet_log; ..\mpu\mllite; ..\mpu\eMPL-hal; ..\mpu_int; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU9250; EMPL_TARGET_STM32L
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group mpu/driver/eMPL
    ../mpu/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group mpu/driver/include
    ../mpu/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group mpu/driver/packet_log
    ../mpu/driver/packet_log/: packet.c packet.h
  group mpu/eMPL-hal
    ../mpu/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group mpu/mllite
    ../mpu/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group mpu/mpl
    ../mpu/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.a mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group mpu/mpu_config
    ../mpu/mpu_config/: mpu_config.c mpu_config.h
  group mpu_int
    ../mpu_int/: mpu_int.c mpu_int.h
  group Peripherals
    ../peripheral/: exti.h exti_stm32l1.c i2c.h i2c_stm32l1.c uart.h uart_stm32l1.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group User
    ../inc/: app_config.c app_config.h discover_board.h main.h stm32l1xx_conf.h stm32l1xx_it.h
    ../src/: main.c stm32l1xx_it.c system_stm32l1xx.c
